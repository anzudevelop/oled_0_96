<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\oled_0_96.ewp</path>
  </project>
  <batchBuild />
</workspace>
